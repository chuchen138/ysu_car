# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\Project;..\System\sys;..\System\delay;..\System\usart;..\HARDWARE\adc;..\HARDWARE\bluetooth_wifi;..\HARDWARE\ir_avoid;..\HARDWARE\ir_trac;..\HARDWARE\ir_yaokong;..\HARDWARE\key_beep;..\HARDWARE\led;..\HARDWARE\motor;..\HARDWARE\sg_90;..\HARDWARE\sr_04;..\HARDWARE\xunguang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../User/: main.c stm32f10x_it.c
  group HARDWARE
    ../HARDWARE/led/: led.c
    ../HARDWARE/bluetooth_wifi/: bluetooth_wifi.c
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/ir_avoid/: ir_avoid.c
    ../HARDWARE/ir_trac/: ir_trac.c
    ../HARDWARE/ir_yaokong/: ir_yaokong.c
    ../HARDWARE/key_beep/: key_beep.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/sg_90/: sg_90.c
    ../HARDWARE/sr_04/: sr_04.c
    ../HARDWARE/xunguang/: xunguang.c
  group SYSTEM
    ../System/sys/: sys.c
    ../System/delay/: delay.c
    ../System/usart/: usart.c
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group DOC
    ../Doc/: readme.txt
